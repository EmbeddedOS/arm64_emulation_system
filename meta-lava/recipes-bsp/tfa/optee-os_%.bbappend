COMPATIBLE_MACHINE:lava-machine = "lava-machine"
DEPENDS += "virtual/bootloader"
